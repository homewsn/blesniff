# IAR project app_core.ewp, settings and files
configuration uart (ARM, debug)
  General.OGChipSelectEditMenu: nrf5340_xxaa_application nRF5340_xxAA_Application
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: NRF5340_XXAA; NRF5340_XXAA_APPLICATION; _APP_CORE_128MHZ
  ICCARM.CCIncludePath2: ..\src; ..\src\hal; ..\src\config; ..\src\messages; ..\..\cmsis\core\include; ..\..\cmsis\device; ..\..\shared\ble; ..\..\shared\config; ..\..\shared\hal; ..\..\shared\messages; ..\..\shared\platform
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app_core.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: nrf5340_app_core.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration usbdev (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NRF5340_XXAA; NRF5340_XXAA_APPLICATION; CFG_TUSB_MCU=OPT_MCU_NRF5X; _APP_CORE_128MHZ
  ICCARM.CCIncludePath2: ..\src; ..\src\hal; ..\src\config; ..\src\messages; ..\src\usb\nrfx; ..\src\usb\tinyusb; ..\..\cmsis\core\include; ..\..\cmsis\device; ..\..\shared\ble; ..\..\shared\config; ..\..\shared\hal; ..\..\shared\messages; ..\..\shared\platform
  group Project
    ../src/: main_uart.c main_usbdev.c serial.c uart.c usb_descriptors.c usbdev.c
  group Project/cmsis
    ../../cmsis/device/: iar_startup_nrf5340_application.s system_nrf5340_application.c
  group Project/config
    ../../shared/config/: ipc_channels.h ipc_msg_types.h mutexes.h shared_memory.h
    ../src/config/: irq_priorities.h
  group Project/hal
    ../../shared/hal/: hal_ipc.c hal_mutex.c
    ../src/hal/: hal_perm.c hal_reset.c hal_uarte.c hal_usbd.c
  group Project/messages
    ../../shared/messages/: msg_queue.c msg_queue_app2net.c msg_queue_net2app.c
    ../src/messages/: msg_queue_ipc2serial.c msg_queue_serial2ipc.c
  group Project/platform
    ../../shared/platform/: platform.c
  group Project/usb/tinyusb
    ../src/usb/tinyusb/class/cdc/: cdc_device.c
    ../src/usb/tinyusb/: dcd_nrf5x.c tusb.c usbc.c usbd.c usbd_control.c
    ../src/usb/tinyusb/common/: tusb_fifo.c
