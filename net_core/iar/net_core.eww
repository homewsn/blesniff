<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\net_core.ewp</path>
    </project>
    <batchBuild />
</workspace>
