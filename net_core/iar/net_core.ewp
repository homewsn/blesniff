# IAR project net_core.ewp, settings and files
configuration radio (ARM, debug)
  General.OGChipSelectEditMenu: nrf5340_xxaa_network nRF5340_xxAA_Network
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: NRF5340_XXAA; NRF5340_XXAA_NETWORK
  ICCARM.CCIncludePath2: ..\src; ..\src\hal; ..\src\config; ..\src\messages; ..\..\cmsis\core\include; ..\..\cmsis\device; ..\..\shared; ..\..\shared\ble; ..\..\shared\config; ..\..\shared\hal; ..\..\shared\messages; ..\..\shared\platform
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: net_core.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: nrf5340_net_core.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Project
    ../src/: adv_header_cache.c channel.c crypto.c main.c radio.c radio_conf_list.c radio_rx_list.c
  group Project/ble
    ../../shared/ble/: ble.c ble.h radio_packet.h
  group Project/cmsis
    ../../cmsis/device/: iar_startup_nrf5340_network.s nrf53_erratas.h system_nrf5340_network.c
  group Project/config
    ../src/config/: dppi_channels.h irq_priorities.h
    ../../shared/config/: ipc_channels.h ipc_msg_types.h mutexes.h shared_memory.h
  group Project/hal
    ../src/hal/: hal_ccm.c hal_dppi.c hal_ecb.c hal_radio.c hal_rt.c
    ../../shared/hal/: hal_ipc.c hal_mutex.c
  group Project/messages
    ../../shared/messages/: msg_queue.c msg_queue_app2net.c msg_queue_net2app.c
    ../src/messages/: msg_queue_rx2decrypt.c
  group Project/platform
    ../../shared/platform/: platform.c
